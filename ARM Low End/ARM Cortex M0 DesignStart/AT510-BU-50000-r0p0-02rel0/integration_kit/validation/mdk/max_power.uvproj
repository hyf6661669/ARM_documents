# Keil uVision project max_power.uvproj, settings and files
target CM0IKMCU - Cortex-M0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: max_power
  AfterMake: fromelf --bin --output ../tests/max_power.bin max_power.axf
  c flags: Optim=1
  c include: ..\tests;..\tests\CMSIS\Core\CM0
  group Boot Files
    ../tests/: boot.c
  group CMSIS Files
    ../tests/CMSIS/Core/CM0/: core_cm0.h core_cm0.c
    ../tests/: cm0ikmcu.h system_cm0ikmcu.h system_cm0ikmcu.c
  group Test Support Files
    ../tests/: retarget_cm0ikmcu.c IKConfig.h IKtests.h IKtests.c debugdriver_functions.h
  group Test
    ../tests/: max_power.c
